Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Plumbing_Drainage_Roca_IN-DRAIN-X3-750-Installation-drainage-ki.ifc
Time: 2020-03-31T13:43:04
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: IN-DRAIN X3 750 Installation drainage kit
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): IN-DRAIN X3 750 Installation drainage kit; SKU (BO_prodsku): 276129000; ManufacturName (BO_Manufac): Roca; BrandUrl (BO_brandurl): http://www.roca.com; ProductFamily (BO_prodfam): In-Drain; ProductGroup (BO_prodgroup): Shower trays; ManufacturCountry (BO_mancont): Spain; DesignCountry (BO_designcont): Spain; EditionNumber (BO_edinum): 1; Width (BO_width): 50; Height (BO_height): 0; Depth (BO_depth): 750; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/roca/product/276129000; ProductDataUrl (BO_prodaturl): bimobject.com/roca/product/276129000; ProductUrl (BO_producturl): http://www.roca.com/catalogue/collections/shower-solutions/shower-trays/drain/drain-x3-installation-drainage-kit-support-ceramic-plate-plate-included-premounted-geotextile-fabric-276129000#!A276129000; InstallationInstructions (BO_montins): http://www.roca.com/RocaResourceServlet/resources/getMainResource?idObject=%7B047F996B-603B-477E-8255-8F51D277BD2A%7D; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=68jtjk-3_i4; BimObjectMainCategory (BO_bomaincat): Plumbing; BimObjectMainCategoryCode (BO_bomaincat_code): plumbing; BimObjectCategory (BO_bocat): Drainage; BimObjectCategoryCode (BO_bocat_code): plumbing-drainage; IfcClassification (BO_ifcclas): Sanitary Terminal; UnspscCode (BO_unspsc): 40141739; Uniclass20Code (BO_uniclass_2_0_code): SS-50-95-20; Uniclass20Description (BO_uniclass_2_0_desc): Domestic Drainage Systems; NBSReference (BO_nbs_ref): 50-95-20; NBSReferenceDescription (BO_nbs_desc): Domestic Drainage Systems; OmniClassCode (BO_omniclass_code): 23-31 17 29; OmniClassDescription (BO_omniclass_name): Shower Drains; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
